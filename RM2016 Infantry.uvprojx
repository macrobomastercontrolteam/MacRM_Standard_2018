# Keil uVision project RM2016 Infantry.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM2016_Infantry
  AfterMake: fromelf.exe  --bin -o ./bin/RM2016_Infantry.bin ./Outputs/RM2016_Infantry.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx
  c include: .\BSP;.\APP;.\STLibraries;.\User;.\MPU6050;.\Protocol;.\FIFO;.\;.\Debug;.\RmLib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c
  group BSP
    ./BSP/: bsp.c led.c gun.c can1.c can2.c delay.c exti.c laser.c timer.c usart1.c usart3.c encoder.c bsp_flash.c
  group Libraries
    ./User/: stm32f4xx_it.c
    ./STLibraries/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c system_stm32f4xx.c stm32f4xx_i2c.c startup_stm32f427xx.s
  group MPU6050
    ./MPU6050/: imu.c mpu6050_i2c.c mpu6050_driver.c mpu6050_interrupt.c
  group Protocol
    ./Protocol/: MF_CRC16.h protocal.h Protocol.lib
  group Task
    ./APP/: IOTask.c ControlTask.c RemoteTask.c CanBusTask.c SuperviseTask.c
  group RmLib
    ./RmLib/: common.h fifo.h LostCounter.h pid_regulator.h ramp.h RMLib.lib
software components: CMSIS:CORE 5.1.2
